# Keil uVision project Project.uvprojx, settings and files
target STM32L486x (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L486ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L486xx,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Middlewares\ST\STM32_Crypto\Inc;..\..\..\..\Middlewares\ST\STM32_Crypto_AccHw\Inc
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l486xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c example_aes128bits_ccm.c example_aes128bits_cfb.c example_aes128bits_keywrap.c example_aes128bits_ofb.c example_aes256bits_xts.c example_ecc_keygen_sign_verify.c example_ecc_sign_verify.c example_poly1305_getmac_verifymac.c example_rsa_encdec.c
  group Doc
    ../: readme.txt aes_128bits_ccm.txt aes_128bits_cfb.txt aes_128bits_keywrap.txt aes_128bits_ofb.txt aes_256bits_xts.txt ecc_keygen_sign_verify.txt ecc_sign_verify.txt poly1305_getmac_veifymac.txt rsa_enc_dec.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c
  group Middlewares/STM32_Crypto/Lib
    ../../../../Middlewares/ST/STM32_Crypto/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_slsm1elfspf.lib STM32CryptographicV3.0.0_CM4_KEIL_otslsm1elfspf.lib
  group Middlewares/STM32_Crypto_AccHw/Lib
    ../../../../Middlewares/ST/STM32_Crypto_AccHw/Lib/: STM32AccHwCryptoV3.1.0_L4_KEIL_otslsm1elfspf.lib STM32AccHwCryptoV3.1.0_L4_KEIL_slsm1elfspf.lib
