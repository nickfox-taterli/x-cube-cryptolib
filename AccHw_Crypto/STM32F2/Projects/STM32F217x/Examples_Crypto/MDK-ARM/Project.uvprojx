# Keil uVision project Project.uvprojx, settings and files
target STM32F217x (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F217IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F217xx
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Middlewares\ST\STM32_Crypto\Inc;..\..\..\..\Middlewares\ST\STM32_Crypto_AccHw\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f217xx.s
  group Application/User
    ../Src/: main.c stm32f2xx_it.c example_aes128bits_ccm.c example_aes128bits_cfb.c example_aes128bits_cmac.c example_aes128bits_gcm.c example_aes128bits_keywrap.c example_aes128bits_ofb.c example_aes256bits_xts.c example_ecc_keygen_sign_verify.c example_ecc_sign_verify.c example_poly1305_getmac_verifymac.c example_rsa_encdec.c
  group Doc
    ../: readme.txt aes_128bits_ccm.txt aes_128bits_cfb.txt aes_128bits_cmac.txt aes_128bits_gcm.txt aes_128bits_keywrap.txt aes_128bits_ofb.txt aes_256bits_xts.txt ecc_keygen_sign_verify.txt ecc_sign_verify.txt poly1305_getmac_veifymac.txt rsa_enc_dec.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_rcc.c stm32f2xx_hal_sram.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c
  group Middlewares/STM32_Crypto/Lib
    ../../../../Middlewares/ST/STM32_Crypto/Lib/: STM32CryptographicV3.0.0_CM3_KEIL_otslsm1elfspf.lib STM32CryptographicV3.0.0_CM3_KEIL_slsm1elfspf.lib
  group Middlewares/STM32_Crypto_AccHw/Lib
    ../../../../Middlewares/ST/STM32_Crypto_AccHw/Lib/: STM32AccHwCryptoV3.1.0_F2_KEIL_otslsm1elfspf.lib STM32AccHwCryptoV3.1.0_F2_KEIL_slsm1elfspf.lib
