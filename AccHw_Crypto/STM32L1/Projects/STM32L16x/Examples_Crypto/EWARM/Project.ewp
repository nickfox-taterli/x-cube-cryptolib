# IAR project Project.ewp, settings and files
configuration STM32L16x (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xE ST STM32L162xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L162xE
  ICCARM.CCIncludePath2: ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Middlewares\ST\STM32_Crypto\Inc; ..\..\..\..\Middlewares\ST\STM32_Crypto_AccHw\Inc; ..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32L152RE-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l162xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l162xc.s
  group Application/User
    ../Src/: example_aes128bits_ccm.c example_aes128bits_cfb.c example_aes128bits_cmac.c example_aes128bits_gcm.c example_aes128bits_keywrap.c example_aes128bits_ofb.c example_aes256bits_xts.c example_ecc_keygen_sign_verify.c example_ecc_sign_verify.c example_poly1305_getmac_verifymac.c example_rand_gen_bytes.c example_rsa_encdec.c main.c stm32l1xx_it.c
  group Doc
    ../: aes_128bits_ccm.txt aes_128bits_cfb.txt aes_128bits_cmac.txt aes_128bits_gcm.txt aes_128bits_keywrap.txt aes_128bits_ofb.txt aes_256bits_xts.txt ecc_keygen_sign_verify.txt ecc_sign_verify.txt poly1305_getmac_veifymac.txt rand_bytes_gen.txt readme.txt rsa_enc_dec.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_spi.c
  group Middlewares/STM32_Crypto/Lib
    ../../../../Middlewares/ST/STM32_Crypto/Lib/: STM32CryptographicV3.0.0_CM3_IAR.a STM32CryptographicV3.0.0_CM3_IAR_otnsc.a
  group Middlewares/STM32_Crypto_AccHw/Lib
    ../../../../Middlewares/ST/STM32_Crypto_AccHw/Lib/: STM32AccHwCryptoV3.1.0_L1_IAR.a STM32AccHwCryptoV3.1.0_L1_IAR_ot.a
