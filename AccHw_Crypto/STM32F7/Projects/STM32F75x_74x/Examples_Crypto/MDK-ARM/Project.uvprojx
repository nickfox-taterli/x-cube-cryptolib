# Keil uVision project Project.uvprojx, settings and files
target STM32F75x (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F756ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32756G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F756xx
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Middlewares\ST\STM32_Crypto\Inc;..\..\..\..\Middlewares\ST\STM32_Crypto_AccHw\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c example_aes128bits_cfb.c example_aes128bits_cmac.c example_aes128bits_keywrap.c example_aes128bits_ofb.c example_aes256bits_xts.c example_ecc_keygen_sign_verify.c example_ecc_sign_verify.c example_poly1305_getmac_verifymac.c example_rsa_encdec.c stm32f7xx_hal_msp.c
  group Doc
    ../: readme.txt aes_128bits_cfb.txt aes_128bits_cmac.txt aes_128bits_keywrap.txt aes_128bits_ofb.txt aes_256bits_xts.txt ecc_keygen_sign_verify.txt ecc_sign_verify.txt poly1305_getmac_veifymac.txt rsa_enc_dec.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c
  group Middlewares/STM32_Cryptographic/Lib
    ../../../../Middlewares/ST/STM32_Crypto/Lib/: STM32CryptographicV3.0.0_CM7_KEIL_slsm1elfspf.lib STM32CryptographicV3.0.0_CM7_KEIL_otslsm1elfspf.lib
  group Middlewares/STM32_Cryptographic_HW/Lib
    ../../../../Middlewares/ST/STM32_Crypto_AccHw/Lib/: STM32AccHwCryptoV3.1.0_F7_KEIL_otslsm1elfspf.lib STM32AccHwCryptoV3.1.0_F7_KEIL_slsm1elfspf.lib
target STM32F74x (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: as above
  output: STM32756G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER ,STM32F746xx
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
