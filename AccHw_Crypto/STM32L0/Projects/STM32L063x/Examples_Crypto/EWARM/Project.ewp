# IAR project Project.ewp, settings and files
configuration STM32L06x (ARM, debug)
  General.OGChipSelectEditMenu: STM32L063x8 ST STM32L063x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L063xx
  ICCARM.CCIncludePath2: ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\Middlewares\ST\STM32_Crypto_AccHw\Inc; ..\..\..\..\Middlewares\ST\STM32_Crypto\Inc; ..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l063xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l063xx.s
  group Application/User
    ../Src/: example_aes128bits_ccm.c example_aes128bits_cfb.c example_aes128bits_cmac.c example_aes128bits_gcm.c example_aes128bits_keywrap.c example_aes128bits_ofb.c example_aes256bits_xts.c example_ecc_keygen_sign_verify.c example_ecc_sign_verify.c example_poly1305_getmac_verifymac.c example_rsa_encdec.c main.c stm32l0xx_it.c
  group Docs
    ../: aes_128bits_ccm.txt aes_128bits_cfb.txt aes_128bits_cmac.txt aes_128bits_gcm.txt aes_128bits_keywrap.txt aes_128bits_ofb.txt aes_256bits_xts.txt ecc_keygen_sign_verify.txt ecc_sign_verify.txt poly1305_getmac_veifymac.txt readme.txt rsa_enc_dec.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group Middlewares/STM32_Crypto/Lib
    ../../../../Middlewares/ST/STM32_Crypto/Lib/: STM32CryptographicV3.0.0_CM0PLUS_IAR.a STM32CryptographicV3.0.0_CM0PLUS_IAR_otnsc.a
  group Middlewares/STM32_Crypto_AccHw/Lib
    ../../../../Middlewares/ST/STM32_Crypto_AccHw/Lib/: STM32AccHwCryptoV3.1.0_L0_IAR.a STM32AccHwCryptoV3.1.0_L0_IAR_otnsc.a
