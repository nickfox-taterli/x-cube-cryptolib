# Keil uVision project Project.uvprojx, settings and files
target STM32756G_EVAL (ARM-ADS)
  device: STM32F756ZG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32756G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32756G_EVAL,STM32F756xx
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\STM32756G_EVAL;..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f756xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../Drivers/BSP/STM32756G_EVAL/: stm32756g_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c
  group Middlewares/STM32_Cryptographic/Lib
    ../../../../../Middlewares/ST/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM7_KEIL_otslsm1elfspf.lib
