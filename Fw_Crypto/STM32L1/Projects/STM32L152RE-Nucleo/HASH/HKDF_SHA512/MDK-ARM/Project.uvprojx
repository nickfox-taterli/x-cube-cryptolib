# Keil uVision project Project.uvprojx, settings and files
target STM32L152RE_NUCLEO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152RE_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L152xE,USE_HAL_DRIVER,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Middlewares\ST\STM32_Cryptographic\Inc;..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c stm32l1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc.c stm32l1xx_hal_adc.c stm32l1xx_hal_spi.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dma.c
  group Middlewares/ST/STM32_Cryptographic/Lib
    ../../../../../Middlewares/ST/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM3_KEIL_otslsm1elfspf.lib
